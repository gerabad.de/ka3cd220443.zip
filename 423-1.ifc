Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/tmp_4972_184_41jV4/format_0/423-1.ifc
Time: 2023-10-05T07:30:01
Made in: PARTsolutions

# IfcProject, 423-1
Description: Duschplan

# IfcDiscreteAccessory, 423-1
In: BUILDING
Description: 423-1
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 423-1
ePset_PARTsolutions - NB: 423-1; NN: 423-1; NT: DUSCHPLAN XXL; NBSYN: $PRODID.; LINA: 423-1; CATALOG: Kaldewei; PRODID: 423-1; DESCRIPTION_SHORT: There are days when you need a lot of space for yourself. And there are days when you want to have a lot of fun for two. Both are possible with the Duschplan Xxl. This is because of its extraordinary size, it gives freedom of movement when showering a completely new dimension.; DESCRIPTION_LONG: The classic shower for two; EF000010: Universal; EF000051: Rectangular; EF020814: false; EF025058: false; EF020363: false; EF002169: -; EF000386: 2,9; EF020621: 12,0; EF001438: 700,0; EF000008: 1400,0; EF000040: 32,0; EF001131: 65,0; EF022185: false; EF025073: false; EF025060: false; EF025074: -; EF000007: Beige; EF024897: Glossy; EF025075: false; EF020710: 90,0; EF025068: true; EF025076: false; EF023789: true; EF000139: Enamelled
